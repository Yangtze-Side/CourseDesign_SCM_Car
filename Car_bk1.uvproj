# Keil uVision project Car_bk1.uvproj, settings and files
target Car (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000)
  output: Car +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: .\Sources\inc;.\User;.\User_Driver;.\User_Lib;.\Motion;.\IMU;.\Algorithm;.\US;.\Communication;.\DHT11;.\Key;.\LED
  group Algorithm
    ./Algorithm/: algorithm.h PosPID.c PosPID.h
  group User
    ./User/: task.c task.h system.c system.h debug.c debug.h
  group User_Driver
    ./User_Driver/: user_driver.h user_pwm.c user_pwm.h user_soft_iic.c user_soft_iic.h user_spi.c user_spi.h user_uart.c user_uart.h
  group User_Lib
    ./User_Lib/: user_lib.h user_math.c user_math.h user_def.h
  group Motion
    ./Motion/: motion.h motor.c motor.h motion_control.c motion_control.h
  group IMU
    ./IMU/: imu_app.c imu_app.h imu_def.c imu_def.h imu_solution_quat.c imu_solution_quat.h MPU6500_SPI.c MPU6500_SPI.h
  group US
    ./US/: us.c us.h
  group Communication
    ./Communication/: communication.c communication.h contract.h
  group DHT11
    ./DHT11/: dht11.c dht11.h
  group Key
    ./Key/: key_SLD.c key_SLD.h
  group LED
    ./LED/: led.c led.h
  group AiCube
    ./Sources/: main.c clock.c port.c timer.c uart.c exti.c spi.c
